// SPDX-License-Identifier: GPL-3.0-or-later
// Copyright (c) 2019-2022 Fabrizio Di Vittorio.
// Изменено для Espresso в 2026 г.


/**
 * @file esp_sound_sine_waveform_generator.h
 * @brief Объявление генератора синусоиды esp::sound::sine_waveform_generator.
 */

/**
 * @file esp_sound_sine_waveform_generator.cpp
 * @brief Генератор синусоиды по таблице.
 */

#include "esp_sound_sine_waveform_generator.h"

#include <cstdint>


#pragma GCC optimize("O2")


namespace esp::sound::p
{

/**
 * @brief Период синусоиды из 256 отсчётов с амплитудой 127.
 *
 * Элемент с номером @c i равен 127 · sin(2π · i / 256), округлённому до
 * целого. Генератор берёт элементы с 0 по 255; последний элемент повторяет
 * первый и не используется.
 */
constexpr std::int8_t SIN_TABLE[257] = {
    0,    3,    6,    9,    12,   16,   19,   22,   25,   28,   31,   34,   37,   40,   43,   46,
    49,   51,   54,   57,   60,   63,   65,   68,   71,   73,   76,   78,   81,   83,   85,   88,
    90,   92,   94,   96,   98,   100,  102,  104,  106,  107,  109,  111,  112,  113,  115,  116,
    117,  118,  120,  121,  122,  122,  123,  124,  125,  125,  126,  126,  126,  127,  127,  127,
    127,  127,  127,  127,  126,  126,  126,  125,  125,  124,  123,  122,  122,  121,  120,  118,
    117,  116,  115,  113,  112,  111,  109,  107,  106,  104,  102,  100,  98,   96,   94,   92,
    90,   88,   85,   83,   81,   78,   76,   73,   71,   68,   65,   63,   60,   57,   54,   51,
    49,   46,   43,   40,   37,   34,   31,   28,   25,   22,   19,   16,   12,   9,    6,    3,
    0,    -3,   -6,   -9,   -12,  -16,  -19,  -22,  -25,  -28,  -31,  -34,  -37,  -40,  -43,  -46,
    -49,  -51,  -54,  -57,  -60,  -63,  -65,  -68,  -71,  -73,  -76,  -78,  -81,  -83,  -85,  -88,
    -90,  -92,  -94,  -96,  -98,  -100, -102, -104, -106, -107, -109, -111, -112, -113, -115, -116,
    -117, -118, -120, -121, -122, -122, -123, -124, -125, -125, -126, -126, -126, -127, -127, -127,
    -127, -127, -127, -127, -126, -126, -126, -125, -125, -124, -123, -122, -122, -121, -120, -118,
    -117, -116, -115, -113, -112, -111, -109, -107, -106, -104, -102, -100, -98,  -96,  -94,  -92,
    -90,  -88,  -85,  -83,  -81,  -78,  -76,  -73,  -71,  -68,  -65,  -63,  -60,  -57,  -54,  -51,
    -49,  -46,  -43,  -40,  -37,  -34,  -31,  -28,  -25,  -22,  -19,  -16,  -12,  -9,   -6,   -3,
    0,
};

}


/**
 * @class esp::sound::sine_waveform_generator
 * @brief Генератор синусоиды.
 *
 * Отсчёты берутся из таблицы периода синусоиды на 256 элементов без
 * интерполяции: номер элемента — старшие 8 разрядов аккумулятора фазы.
 * Частота волны задаётся в герцах и должна быть меньше половины частоты
 * дискретизации, иначе возникают искажения наложения спектра; при частоте
 * выше 8191 Гц, кроме того, переполняется вычисление приращения фазы.
 */


// Открытые

/**
 * @brief Создаёт генератор с нулевой частотой: до set_frequency() он молчит.
 */
esp::sound::sine_waveform_generator::sine_waveform_generator()
    : _phase_inc{0}
    , _phase_acc{0}
    , _frequency{0}
    , _last_sample{0}
{
}

/**
 * @brief Задаёт частоту синусоиды.
 *
 * Приращение фазы пересчитывается, только если частота изменилась; фаза
 * при этом не сбрасывается.
 *
 * @param value Частота, Гц; 0 — тишина.
 * @pre Генератор подключён к генератору звука
 *      (esp::sound::sound_generator::attach()): до подключения частота
 *      дискретизации равна нулю, и деление на неё вызывает исключение
 *      процессора.
 */
void esp::sound::sine_waveform_generator::set_frequency(int value)
{
    if (_frequency != value)
    {
        _frequency = value;
        // За секунду фаза должна _frequency раз пройти 256 элементов таблицы
        // (с 11 дробными разрядами) за sample_rate() отсчётов.
        _phase_inc = ((static_cast<std::uint32_t>(_frequency) * 256) << 11) / sample_rate();
    }
}

/**
 * @brief Выдаёт следующий отсчёт синусоиды.
 *
 * При нулевой частоте или истёкшей длительности выход сходит к нулю на
 * единицу за отсчёт; когда он дошёл до нуля, фаза сбрасывается.
 *
 * @return Отсчёт от −127 до 127 с учётом громкости.
 */
int esp::sound::sine_waveform_generator::sample()
{
    if (!_frequency || !duration())
    {
        // Плавное затухание вместо обрыва: скачок к нулю слышен как щелчок.
        if (_last_sample > 0)
            --_last_sample;
        else if (_last_sample < 0)
            ++_last_sample;
        else
            _phase_acc = 0;
        return _last_sample;
    }

    // Номер элемента таблицы — целая часть фазы.
    const std::uint32_t index = _phase_acc >> 11;
    int value = esp::sound::p::SIN_TABLE[index];

    // Громкость.
    value = value * volume() / 127;

    _last_sample = value;

    _phase_acc = (_phase_acc + _phase_inc) & 0x7ffff;

    dec_duration();

    return value;
}
